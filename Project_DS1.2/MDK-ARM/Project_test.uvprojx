# Keil uVision project Project_test.uvprojx, settings and files
target Project_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC,ARM_MATH_CM4
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\Drivers\ARMMAT\Include;    ..\Task_LL\task_attitude;    ..\Driver_LL\driver_mpu6050;    ..\Math_function\kalmanfilter;    ..\Driver_LL\driver_motor;    ..\Math_function\pid;    ..\Task_LL\task_motor;    ..\Driver_LL\driver_hanging;    ..\Task_LL\task_hanging;    ..\Driver_LL\driver_i2cunlock;    ..\Driver_LL\driver_mpu6050\eMPL;    ..\Math_function
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Drivers/ARMMAT/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../Src/: system_stm32f1xx.c
  group Task
    ../Task_LL/task_attitude/: task_attitude.c
    ../Task_LL/task_motor/: task_motor.c
    ../Task_LL/task_hanging/: task_hanging.c
  group Driver
    ../Driver_LL/driver_mpu6050/: driver_mpu6050.c
    ../Driver_LL/driver_motor/: driver_motor.c
    ../Driver_LL/driver_hanging/: driver_hanging.c
    ../Driver_LL/driver_i2cunlock/: driver_i2cunlock.c
  group Math_fnc
    ../Math_function/kalmanfilter/: kalman_filter.c
    ../Math_function/pid/: pid.c
software components: CMSIS:CORE 4.3.0
